## boards/shields/pmw3610-xiao/Kconfig.defconfig
```kconfig
if SHIELD_PMW3610_XIAO

config ZMK_KEYBOARD_NAME
    default "PMW3610_XIAO"

endif
```
